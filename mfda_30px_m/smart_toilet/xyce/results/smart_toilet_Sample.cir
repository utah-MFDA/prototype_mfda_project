YPressurePump soln1 1 2 pressure=100k
Ychannel soln1_channel 1 3 2 4 length=8.244000000000002m

YPressurePump soln2 5 6 pressure=100k
Ychannel soln2_channel 5 7 6 8 length=7.220000000000002m

YPressurePump soln3 9 10 pressure=100k chemConcentration=100m
Ychannel soln3_channel 9 11 10 12 length=9.584000000000001m

Ychannel output0 13 0 14 15 length=4.596000000000001m
Ychannel connect01 16 17 18 19 length=2.396m
Ychannel connect02 20 21 22 23 length=4.904000000000001m
Ychannel connect0 24 25 26 27 length=3.764000000000001m
Ychannel connect1 28 29 30 31 length=7.928000000000002m
Ychannel connect2 32 33 34 35 length=4.620000000000001m
Ychannel connect3 36 37 38 39 length=5.076000000000001m
Ychannel connect5 40 41 42 43 length=8.296m
Ychannel connect6 44 45 46 47 length=3.540000000000001m
Ychannel connect31 48 49 50 51 length=2.968000000000001m
Ychannel connect32 52 53 54 55 length=6.444000000000002m
Ychannel connect33 56 57 58 59 length=3.592000000000001m
Ychannel connect34 60 61 62 63 length=5.132000000000001m
Ychannel connect35 64 65 66 67 length=5.132000000000001m
Ychannel connect36 68 69 70 71 length=5.760000000000002m
Ychannel connect37 72 73 74 75 length=5.420000000000002m
Yserpentine_200px_0 serp1 7 24 8 26
Yserpentine_200px_0 serp1_1 25 16 27 18
Yserpentine_200px_0 serp1_2 17 20 19 22
Yserpentine_200px_0 serp2 21 28 23 30
Ydiffmix_25px_0 mix0 3 29 32 4 31 34
Yserpentine_300px_2 serp4 11 36 12 38
Yserpentine_300px_2 serp6 37 48 39 50
Yserpentine_300px_2 serp6_1 49 52 51 54
Yserpentine_300px_2 serp6_2 53 56 55 58
Yserpentine_300px_2 serp6_3 57 60 59 62
Yserpentine_300px_2 serp6_4 61 64 63 66
Yserpentine_300px_2 serp6_5 65 68 67 70
Yserpentine_300px_2 serp6_6 69 72 71 74
Yserpentine_300px_2 serp6_10 73 40 75 42
Ydiffmix_25px_0 mix1 33 41 44 35 43 46
Yserpentine_200px_0 serp7 45 13 47 14

.tran 0.1m 1m
.print tran V(14)
.end
